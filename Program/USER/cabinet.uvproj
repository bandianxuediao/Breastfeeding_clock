# Keil uVision project cabinet.uvproj, settings and files
target cabinet (ARM-ADS)
  device: STM32L152VD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: cabinet +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM;..\USER;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\Msg_Process;..\User_app;..\HARDWARE\Irmp;..\HARDWARE\OLED;..\HARDWARE\HZ_Char;..\HARDWARE\RC531;..\HARDWARE\w25qxx;..\HARDWARE\TouchPad;..\HARDWARE\EEPROM;..\HARDWARE\exti
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../User_app/: main.c
  group user_app
    ../User_app/: stm32f10x_it.c keyScan.c MidFunction.c
    ../HARDWARE/OLED/: display.c
  group Hardware
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c ST7920.c
    ../HARDWARE/exti/: exti.c
  group EEPROM
    ../HARDWARE/EEPROM/: EE_IIC.c EE_24C128.c
  group Stm32f103_Fwlib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group Core
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group DOC
    ./: record.txt
